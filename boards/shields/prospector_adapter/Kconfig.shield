## boards/shields/prospector_adapter/Kconfig.shield
```kconfig
config SHIELD_PROSPECTOR_ADAPTER
    def_bool $(shields_list_contains,prospector_adapter)
```
